# IAR project LED.ewp, settings and files
configuration EMB_FLASH (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCDefines: EMB_FLASH
  ICCARM.CCIncludePath2: ; board\; Library\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: LED.hex
  ILINK.IlinkOutputFile: LED.out
  ILINK.IlinkIcfFile: config\STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: config.h main.c startup_stm32f10x_md.s
